## sdkconfig.defaults
```kconfig
CONFIG_LOG_DEFAULT_LEVEL_WARN=y
CONFIG_LOG_MAXIMUM_LEVEL_INFO=y
CONFIG_ESP_COREDUMP_ENABLE_TO_NONE=y
```
